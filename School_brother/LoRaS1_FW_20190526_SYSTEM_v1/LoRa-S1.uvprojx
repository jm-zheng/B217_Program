# Keil uVision project LoRa-S1.uvprojx, settings and files
target LoRa-S1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LoRa-S1 +hex
  AfterMake: fromelf --bin ".\out\@L.axf" --output ".\out\@L.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB
  c misc: --C99
  c include: .\;.\Drivers\STM32F0xx_HAL_Driver\Inc;.\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Device\ST\STM32F0xx\Include;.\Drivers\CMSIS\Include;.\Drivers\module
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ./Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_rtc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c
    ./: stm32f0xx_hal_conf.h
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ./: main.c uart.c board.c
    ./: task.c library.c define.h
    ./Drivers/module/: M200_1.c M200_2.c M650.c
software components: CMSIS:CORE 5.0.0
