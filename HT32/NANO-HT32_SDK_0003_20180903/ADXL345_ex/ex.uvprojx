# Keil uVision project ex.uvprojx, settings and files
target ex (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IROM(0x00000000-0x0001FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: ex +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: .\;..\Drivers\CMSIS\Include;..\Drivers\Device\Holtek\HT32F5xxxx\Include;..\Drivers\HT32F5xxxx_Driver\inc;..\Library
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ./: Main.cpp
  group Library
    ../Library/: HT32IO.cpp OLED.cpp Print.cpp Stream.cpp WString.cpp ht32f5xxxx_01_it.c SoftwareWire.cpp ADXL345.cpp
  group Config
    ../Library/: ht32_op.s ht32f5xxxx_conf.h
  group Device
    ../Drivers/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_01.s
    ../Drivers/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_01.c
  group Drivers
    ../Drivers/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../Drivers/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
